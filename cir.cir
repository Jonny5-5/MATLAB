Vb 1 0 12
Rc 1 2 4
Rd 2 0 3
Va 3 0 25
Ra 3 4 1
Rb 4 5 5
O1 2 4 5
